# IAR project libboard_sam9g15.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: sam9g15 Atmel sam9g15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sam9g15; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ../../; ../../../libchip_sam9xx5/; ../../../libsdmmc/
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: sam9g15
  ILINK.IlinkOutputFile: libsam9g15.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sam9g15
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libboard_sam9g15-ek.out
  group (top)
    ../../: board.h
  group include
    ../../include/: bitbanding.h bmp.h board_lowlevel.h board_memories.h clock.h dbg_util.h dmad.h hamming.h lcd_color.h lcd_font.h lcd_font10x14.h lcdd.h led.h math.h mcid.h mii.h rand.h tsd.h tsd_com.h uart_console.h wav.h wm8731.h
    ../../source/: qt1070.h
  group source
    ../../source/: bmp.c board_cstartup_iar.s board_lowlevel.c board_memories.c clock.c dbg_util.c dbgu_console.c dma_hardware_interface.c dmad.c hamming.c lcd_draw.c lcd_font.c lcd_font10x14.c lcdd.c led.c math.c mcid_dma.c qt1070.c rand.c timetick.c trace.c tsd_com.c tsd_tsadc.c wav.c wm8731.c
