<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\libboard_sam9g15.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libboard_sam9g25.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libboard_sam9g35.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libboard_sam9x25.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libboard_sam9x35.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>build_all</name>
      <member>
        <project>libboard_sam9g15-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam9g15-ek</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libboard_sam9g25-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam9g25-ek</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libboard_sam9g35-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam9g35-ek</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libboard_sam9x25-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam9x25-ek</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libboard_sam9x35-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam9x35-ek</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


