# IAR project libsdmmc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: sam9g25 Atmel sam9g25
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sam9g25; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../../libboard_sam9xx5-ek; ../../; ../../../libchip_sam9xx5/; ../../../libsdmmc/; ../../../libsdmmc/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: sam9g25
  ILINK.IlinkOutputFile: libsdmmc.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sam9g25
  ICCARM.CCIncludePath2: ../../; ../../../libchip_sam9xx5/; ../../../libsdmmc/; ../../../libsdmmc/include/
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: libsdmmc.h
  group include
    ../../include/: sdio.h sdmmc.h sdmmc_cmd.h sdmmc_dbg.h sdmmc_hal.h sdmmc_trace.h
  group source
    ../../source/: sdmmc.c
