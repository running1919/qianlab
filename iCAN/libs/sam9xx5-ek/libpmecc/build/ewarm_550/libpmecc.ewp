# IAR project libpmecc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: sam9g25 Atmel sam9g25
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sam9g25; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ../../../libboard_sam9xx5-ek; ../../; ../../../libchip_sam9xx5/; ../../../libpmecc/
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: sam9g25
  ILINK.IlinkOutputFile: libpmecc.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sam9g25
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: board.h
  group include
    ../../include/: pmecc.h pmecc_gallois_field_1024.h pmecc_gallois_field_512.h
  group source
    ../../source/: pmecc.c pmecc_gallois_field_1024.c pmecc_gallois_field_512.c
