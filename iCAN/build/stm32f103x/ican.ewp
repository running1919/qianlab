# IAR project ican.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.PreInclude: ..\..\init\stm32f103x\stm32f10x.h
  ICCARM.CCIncludePath2: ..\..\; ..\..\include\stm32f103x\; ..\..\libs\stm32f10x-ek\STM32F10x_StdPeriph_Driver\inc; ..\..\init\stm32f103x; ..\..\driver\stm32f103x
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ican.bin
  ILINK.IlinkOutputFile: ican.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../test/: test_stm32f10x.c
  group driver/stm32f103x
    ../../driver/stm32f103x/: cand.c cand.h clock.c clock.h delay.c delay.h flash.c flash.h io.c io.h iwdg.c iwdg.h timer.c timer.h usart.c usart.h
  group driver/stm32f103x/cortexM3
    ../../driver/stm32f103x/CortexM3/: bitband.c bitband.h
  group iCAN/can
    ../../iCAN/can/: can_hal.c can_hal.h can_sam9x25.c can_sam9x25.h can_stm32f103x.c can_stm32f103x.h
  group iCAN/ican
    ../../iCAN/ican/: ican.c ican.h ican_master.c ican_master.h ican_slave.c ican_slave.h
  group iCAN/include
    ../../iCAN/include/: can_config.h can_type.h ican_API.h ican_config.h ican_error.h ican_type.h
  group iCAN/lib
    ../../iCAN/lib/: ican_stdio.c ican_stdio.h ican_timer.c ican_timer.h
  group include/stm32f103x
    ../../include/stm32f103x/: driver_api.h
  group init/stm32f103x
    ../../init/stm32f103x/: startup_stm32f10x_md.s stm32f10x.h stm32f10x_conf.h stm32f10x_init.c stm32f10x_init.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group libs/STM32F10x_StdPeriph_Driver/inc
    ../../libs/stm32f10x-ek/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group libs/STM32F10x_StdPeriph_Driver/src
    ../../libs/stm32f10x-ek/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
