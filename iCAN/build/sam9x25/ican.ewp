# IAR project ican.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X25 Atmel SAM9X25
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sam9x25; ddram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../libs/sam9xx5-ek; ../../libs/sam9xx5-ek/libboard_sam9xx5-ek; ../../libs/sam9xx5-ek/libchip_sam9xx5
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: sam9x25; ddram; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\libs
  OBJCOPY.OOCOutputFile: ican.bin
  ILINK.IlinkOutputFile: ican.out
  ILINK.IlinkIcfFile: ../../libs/sam9xx5-ek/libboard_sam9xx5-ek/resources/ewarm/sam9x25/ddram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../test/: test_sam9x25.c
  group iCAN/can
    ../../iCAN/can/: can_hal.c can_hal.h can_sam9x25.c can_sam9x25.h
  group iCAN/ican
    ../../iCAN/ican/: ican.c ican.h ican_master.c ican_master.h ican_slave.c ican_slave.h
  group iCAN/include
    ../../iCAN/include/: can_config.h can_type.h ican_API.h ican_config.h ican_error.h ican_type.h
  group iCAN/lib
    ../../iCAN/lib/: ican_stdio.c ican_stdio.h ican_timer.c ican_timer.h
  group libs
    ../../libs/sam9xx5-ek/libboard_sam9xx5-ek/lib/: libboard_sam9x25_ek_ewarm_dbg.a
    ../../libs/sam9xx5-ek/libchip_sam9xx5/lib/: libchip_sam9x25_ewarm_dbg.a
  group resouces
    ../../libs/sam9xx5-ek/libboard_sam9xx5-ek/resources/ewarm/sam9x25/: ddram.icf
