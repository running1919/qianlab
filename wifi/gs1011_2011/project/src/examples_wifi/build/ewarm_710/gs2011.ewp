# IAR project gs2011.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X25 Atmel SAM9X25
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sam9x25; ddram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../../../libraries; ../../../../libraries/libboard_sam9xx5-ek; ../../../../libraries/libchip_sam9xx5
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: sam9x25; ddram; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\..\libraries
  OBJCOPY.OOCOutputFile: ddram.bin
  ILINK.IlinkOutputFile: ddram.out
  ILINK.IlinkIcfFile: ../../../../libraries/libboard_sam9xx5-ek/resources/ewarm/sam9x25/ddram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group (top)
    ../../: main.c
  group documentation
    ../../../documentation/html/: spi_library.html
  group drv/wifi
    ../../drv/wifi/: wifi.h
  group drv/wifi/gs2011/API
    ../../drv/wifi/gs2011/API/: GS_API.h GS_API_device.c GS_API_network.c GS_API_platform.c GS_API_private.h
  group drv/wifi/gs2011/APP
    ../../drv/wifi/gs2011/APP/: GS_App.h GS_App_firmware_update.c GS_App_join_network.c GS_APP_provisioning.c GS_App_sleep.c GS_App_tcp.c GS_App_udp.c
  group drv/wifi/gs2011/AT
    ../../drv/wifi/gs2011/AT/: AtCmdLib.c AtCmdLib.h
  group drv/wifi/gs2011/platform
    ../../drv/wifi/gs2011/platform/: GS_HAL.c GS_HAL.h GS_mstimer.c GS_mstimer.h GS_spi_SAM9X25.c GS_spi_SAM9X25.h GS_spidma_SAM9X25.c GS_spidma_SAM9X25.h
  group libraries
    ../../../../libraries/libboard_sam9xx5-ek/lib/: libboard_sam9x25_ek_ewarm_dbg.a
    ../../../../libraries/libchip_sam9xx5/lib/: libchip_sam9x25_ewarm_dbg.a
  group resources
    ../../../libraries/libboard_sam9xx5-ek/resources/ewarm/sam9x25/: ddram.icf
