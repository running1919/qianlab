<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\libusb_sam9xx5.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>build_all</name>
      <member>
        <project>libusb_sam9xx5</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libusb_sam9xx5</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


