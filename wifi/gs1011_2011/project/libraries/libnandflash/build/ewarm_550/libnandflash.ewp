# IAR project libnandflash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: sam9g25 Atmel sam9g25
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sam9g25; TRACE_LEVEL=1
  ICCARM.CCIncludePath2: ../../../libboard_sam9xx5-ek; ../../; ../../../libchip_sam9xx5/; ../../../libnandflash/; ../../../libpmecc/
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: sam9g25
  ILINK.IlinkOutputFile: libnandflash.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sam9g25
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../: board.h
  group include
    ../../include/: EccNandFlash..h NandCommon.h NandFlashDma..h NandFlashModel.h NandFlashModelList.h NandFlashOnfi.h NandSpareScheme.h RawNandFlash.h SkipBlockNandFlash.h
  group source
    ../../source/: EccNandFlash.c NandFlashDma.c NandFlashModel.c NandFlashModelList.c NandFlashOnfi.c NandSpareScheme.c RawNandFlash.c SkipBlockNandFlash.c
