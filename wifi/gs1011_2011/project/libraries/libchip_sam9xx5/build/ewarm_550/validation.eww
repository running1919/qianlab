<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\libchip_sam9g35.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libchip_sam9g25.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libchip_sam9g15.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libchip_sam9x25.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libchip_sam9x35.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>libchip_sam9g15</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam9g25</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam9g35</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam9x25</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam9x35</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>libchip_sam9g15</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam9g25</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam9g35</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam9x25</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam9x35</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>build_all</name>
      <member>
        <project>libchip_sam9g15</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam9g15</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam9g25</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam9g25</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam9g35</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam9g35</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam9x25</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam9x25</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam9x35</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam9x35</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


